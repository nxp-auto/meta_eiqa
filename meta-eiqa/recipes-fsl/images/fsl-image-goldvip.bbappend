IMAGE_INSTALL += "eiqa-runtime-prebuilt"
